# IAR project Balance_Robot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1; UART_BUFFERED
  ICCARM.CCIncludePath2: ; Libraries\; Hardware\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Balance_Robot.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group Hardware
    Hardware/: hal_clock.c hal_clock.h hal_gpio.c hal_gpio.h hal_uart.c hal_uart.h
  group inc
    inc/: asmdefs.h hw_adc.h hw_can.h hw_comp.h hw_eeprom.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h inc.sgxx tm4c123gh6pm.h
  group Libraries/DriverLib
    Libraries/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpu.c cpu.h debug.h eeprom.c eeprom.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group Libraries/USBLib
    Libraries/usblib/: usb-ids.h usbaudio.h usbbuffer.c usbcdc.h usbdesc.c usbdfu.h usbdma.c usbhid.h usbkeyboardmap.c usblibpriv.h usbmode.c usbmsc.h usbringbuf.c usbtick.c
  group Libraries/USBLib/device
    Libraries/usblib/device/: usbdaudio.c usbdaudio.h usbdbulk.c usbdbulk.h usbdcdc.c usbdcdc.h usbdcdesc.c usbdcomp.c usbdcomp.h usbdconfig.c usbddfu-rt.c usbddfu-rt.h usbdenum.c usbdevice.h usbdevicepriv.h usbdhandler.c usbdhid.c usbdhid.h usbdhidkeyb.c usbdhidkeyb.h usbdhidmouse.c usbdhidmouse.h usbdmsc.c usbdmsc.h
  group Libraries/USBLib/host
    Libraries/usblib/host/: usbhaudio.c usbhaudio.h usbhhid.c usbhhid.h usbhhidkeyboard.c usbhhidkeyboard.h usbhhidmouse.c usbhhidmouse.h usbhhub.c usbhhub.h usbhmsc.c usbhmsc.h usbhost.h usbhostenum.c usbhostpriv.h usbhscsi.c usbhscsi.h
  group Startup
    Startup/: startup_ewarm.c
