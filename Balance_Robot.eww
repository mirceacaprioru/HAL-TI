<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Balance_Robot.ewp</path>
  </project>
  <batchBuild/>
</workspace>


