<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Globals</name>
    <file>
      <name>$PROJ_DIR$\Globals\log.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Globals\log.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Globals\typedefs.h</name>
    </file>
  </group>
  <group>
    <name>Hardware</name>
    <file>
      <name>$PROJ_DIR$\Hardware\hal_clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\hal_clock.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\hal_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\hal_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\hal_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\hal_uart.h</name>
    </file>
  </group>
  <group>
    <name>inc</name>
    <file>
      <name>$PROJ_DIR$\inc\asmdefs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_can.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_comp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_eeprom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_fan.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_hibernate.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_ints.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_lpc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_memmap.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_nvic.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_peci.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_pwm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_qei.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_ssi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_sysctl.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_sysexc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_timer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_types.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_udma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_usb.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hw_watchdog.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\inc.sgxx</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\tm4c123gh6pm.h</name>
    </file>
  </group>
  <group>
    <name>Libraries</name>
    <group>
      <name>DriverLib</name>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\comp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\comp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\cpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\debug.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\eeprom.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\eeprom.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\fpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\fpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\hibernate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\hibernate.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\interrupt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\interrupt.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\mpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\mpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\pin_map.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\pwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\pwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\qei.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\qei.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\rom.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\rom_map.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\rtos_bindings.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\ssi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\ssi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\sw_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\sw_crc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\sysctl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\sysctl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\sysexc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\sysexc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\systick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\systick.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\udma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\udma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\usb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\usb.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\watchdog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\driverlib\watchdog.h</name>
      </file>
    </group>
    <group>
      <name>USBLib</name>
      <group>
        <name>device</name>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdaudio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdaudio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdbulk.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdbulk.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdcdc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdcdc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdcdesc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdcomp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdcomp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdconfig.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbddfu-rt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbddfu-rt.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdenum.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdevice.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdevicepriv.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdhandler.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdhid.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdhid.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdhidkeyb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdhidkeyb.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdhidmouse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdhidmouse.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdmsc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\device\usbdmsc.h</name>
        </file>
      </group>
      <group>
        <name>host</name>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhaudio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhaudio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhhid.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhhid.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhhidkeyboard.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhhidkeyboard.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhhidmouse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhhidmouse.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhhub.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhhub.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhmsc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhmsc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhost.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhostenum.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhostpriv.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhscsi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\usblib\host\usbhscsi.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usb-ids.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbaudio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbbuffer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbcdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbdesc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbdfu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbdma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbhid.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbkeyboardmap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usblibpriv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbmode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbmsc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\usblib\usbtick.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Peripherals</name>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\Startup\startup_ewarm.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


